## overlay/src/modules/shared_tilt_control/Kconfig
```kconfig
menuconfig MODULES_SHARED_TILT_CONTROL
	bool "Shared-tilt shadow and fixed SITL bench"
	default n
	depends on PLATFORM_POSIX
```
